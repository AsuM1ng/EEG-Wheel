#include "sdo_frames.h"
#include "can_driver.h"
#include <string.h>

const SDO_Frame SDO_ACTIVATE_INIT     = {2, {0x01,0x00}};
const SDO_Frame SDO_ACTIVATE_PPM      = {5, {0x2F,0x60,0x60,0x00,0x01}};
const SDO_Frame SDO_ACTIVATE_SETV2000 = {8, {0x23,0x81,0x60,0x00,0x88,0x13,0x00,0x00}};
const SDO_Frame SDO_ACTIVATE_SETV1000 = {8, {0x23,0x81,0x60,0x00,0xE8,0x30,0x00,0x00}};
const SDO_Frame SDO_ACTIVATE_SETV100  = {8, {0x23,0x81,0x60,0x00,0x64,0x00,0x00,0x00}};
const SDO_Frame SDO_DISABLE           = {6, {0x2B,0x40,0x60,0x00,0x06,0x00}};
const SDO_Frame SDO_ENABLE            = {6, {0x2B,0x40,0x60,0x00,0x0F,0x00}};
const SDO_Frame SDO_GO                = {6, {0x2B,0x40,0x60,0x00,0x5F,0x00}};

/* 下面按节点拆分目标位置/速度报文，可继续扩展 */
const SDO_Frame SDO_TARGET_POS_NODE10000  = {8, {0x23,0x7A,0x60,0x00,0x10,0x27,0x00,0x00}};
const SDO_Frame SDO_TARGET_POS_NODE1000   = {8, {0x23,0x7A,0x60,0x00,0xE8,0x03,0x00,0x00}};
const SDO_Frame SDO_TARGET_POS_NODE2000   = {8, {0x23,0x7A,0x60,0x00,0xD0,0x07,0x00,0x00}};
const SDO_Frame SDO_TARGET_POS_NODE5000   = {8, {0x23,0x7A,0x60,0x00,0x88,0x13,0x00,0x00}};

const SDO_Frame SDO_TARGET_POS_NODEUN10000  = {8, {0x23, 0x7A, 0x60, 0x00, 0xF0, 0xD8, 0xFF, 0xFF}};
const SDO_Frame SDO_TARGET_POS_NODEUN1000   = {8, {0x23, 0x7A, 0x60, 0x00, 0x18, 0xFC, 0xFF, 0xFF}};
const SDO_Frame SDO_TARGET_POS_NODEUN2000   = {8, {0x23, 0x7A, 0x60, 0x00, 0x30, 0xF8, 0xFF, 0xFF}};
const SDO_Frame SDO_TARGET_POS_NODEUN5000   = {8, {0x23, 0x7A, 0x60, 0x00, 0x78, 0xEC, 0xFF, 0xFF}};


const SDO_Frame SDO_TARGET_POS_NODE100 = {8, {0x23, 0x7A, 0x60, 0x00, 0x64, 0x00, 0x00, 0x00}};
const SDO_Frame SDO_TARGET_POS_NODEUN100 = {8, {0x23, 0x7A, 0x60, 0x00, 0x9C, 0xFF, 0xFF, 0xFF}};
const SDO_Frame SDO_TARGET_POS_NODE200 = {8, {0x23, 0x7A, 0x60, 0x00, 0xC8, 0x00, 0x00, 0x00}};
const SDO_Frame SDO_TARGET_POS_NODEUN200 = {8, {0x23, 0x7A, 0x60, 0x00, 0x38, 0xFF, 0xFF, 0xFF}};
const SDO_Frame SDO_TARGET_POS_NODE500 = {8, {0x23, 0x7A, 0x60, 0x00, 0xF4, 0x01, 0x00, 0x00}};
const SDO_Frame SDO_TARGET_POS_NODEUN500 = {8, {0x23, 0x7A, 0x60, 0x00, 0x0C, 0xFE, 0xFF, 0xFF}};

UNS8 send_sdo_to_node(UNS8 node_id, const SDO_Frame *frame)
{
    Message tx = {0};

    if (frame == 0 || frame->len > SDO_MAX_DATA_LEN) {
        return 0;
    }

    tx.cob_id = 0x600 + node_id; /* 例如 node_id=1 => 0x601 */
    tx.len = frame->len;
    tx.rtr = 0;
    memcpy(tx.data, frame->data, frame->len);

    return canSend(0, &tx);
}

// ========== 状态字读取实现 ==========
// g_statusword 定义在 epos_api.c 中，此处仅引用
extern volatile uint16_t g_statusword[5];

// 发送读状态字请求 (SDO Upload: 0x6041)
void request_statusword(UNS8 node_id)
{
    Message tx = {0};
    tx.cob_id = 0x600 + node_id;
    tx.len = 4;
    tx.rtr = 0;
    tx.data[0] = 0x40;        // SDO Upload Request
    tx.data[1] = 0x41;        // Index low
    tx.data[2] = 0x60;        // Index high (0x6041)
    tx.data[3] = 0x00;        // Subindex
    canSend(0, &tx);
}

// 检查节点是否到位
u8 is_node_reached(UNS8 node_id)
{
    // Bit 12: Set-point acknowledged (目标位置已到达)
    return (g_statusword[node_id] & 0x1000) ? 1 : 0;
}

// 检查多个节点是否全部到位
u8 are_all_nodes_reached(u8 node_mask)
{
    u8 i;
    for (i = 1; i <= 4; i++) {
        if ((node_mask & (1 << (i-1))) && !is_node_reached(i)) {
            return 0;
        }
    }
    return 1;
}
